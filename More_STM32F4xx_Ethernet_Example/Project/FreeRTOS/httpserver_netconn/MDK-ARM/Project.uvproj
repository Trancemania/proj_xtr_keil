# Keil uVision project Project.uvproj, settings and files
target Discover-More (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\inc;..\src;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\Utilities\lwip_v1.3.2\src\include;..\..\..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\FreeRTOS_v6.1.0\include;..\..\..\..\Utilities\FreeRTOS_v6.1.0\portable\MDK-ARM\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c netconf.c stm32f4x7_eth_bsp.c fs.c httpserver-netconn.c custom_stm32f4_board.c tm_stm32f4_dma.c tm_stm32f4_usart.c tm_stm32f4_usart_dma.c tm_stm32f4_gpio.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_tim.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LWIP
    ../../../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/lwip_v1.3.2/src/core/: udp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c dns.c dhcp.c
    ../../../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../../Utilities/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../../Utilities/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
    ../../../../Utilities/FreeRTOS_v6.1.0/portable/MDK-ARM/ARM_CM3/: port.c
    ../../../../Utilities/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group Readme
    ../: readme.txt
